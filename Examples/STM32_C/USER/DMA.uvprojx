# Keil uVision project DMA.uvprojx, settings and files
target DMA (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743IIKx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: MT_IMU_STM32H743 +hex
  AfterMake: fromelf.exe --bin -o "MT_IMU_STM32H743.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx,ARM_MATH_CM7,__FPU_PRESENT,SPI_ANALOG_MEAN
  c include: ..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32H7xx_HAL_Driver\Inc;..\HARDWARE\TIMER;..\HARDWARE\MPU;..\HARDWARE\SDRAM;..\HARDWARE\DMA;..\HARDWARE\STMFLASH;..\MATH\DSP\Include;..\MATH;..\SINS;..\DATASTRUCTURE\inc;..\SYSTEM;..\MATH;..\HARDWARE\MAX1486;..\HARDWARE\MT_IMU
  memory RVCT4: ROM 0x8000000 size 0xe0000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group USER
    ./: main.c stm32h7xx_it.c system_stm32h7xx.c stm32h7xx_hal_msp.c includes.h
  group CORE
    ../CORE/: cmsis_compiler.h core_cm7.h cmsis_armcc.h startup_stm32h743xx.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c usart2.c
  group HALLIB
    ../HALLIB/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sram.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c
  group HARDWARE
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/MAX1486/: MAX1486.c
  group MATH
    ../MATH/DSP/Lib/ARM/: arm_cortexM7lfdp_math.lib
  group MTIMU
    ../HARDWARE/MT_IMU/: imu.c
    ../DATASTRUCTURE/: check_alg.c
